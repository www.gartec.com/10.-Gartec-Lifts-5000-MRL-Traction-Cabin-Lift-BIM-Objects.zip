Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-02-14T17:55:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20171027_0315(x64) - Exporter 17.0.1150.0 - Alternate UI 17.19.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 14 17:55:34 2019 * Host: MSI * Database: C:\Users\RAMSKI~1\AppData\Local\Temp\{BA06CDE1-5B99-47BD-B65A-90EED47D8C39}\ifc * Database version: 5507 * Database creation date: Thu Feb 14 17:55:32 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 14 17:55:32 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 14 17:55:32 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: 6 Floor, Gartec-5000-MRL-Traction-Cabin-Lift:6 Floor:275700
In: Level 0
Type - Material: LiftShaft, LiftDoor, LiftCabin, SteelFrame
Pset_BuildingElementProxyCommon - Reference: 6 Floor
Pset_ManufacturerTypeInformation - Manufacturer: sales@gartec.com
